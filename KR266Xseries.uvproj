# Keil uVision project KR266Xseries.uvproj, settings and files
target KR266Xseries (MCS-51)
  device: W79E632 Winbond
  cpu: IRAM(0 - 0xFF) IROM(0-0xFFFF)  XRAM(0-0x3FF) CLOCK(40000000)MODDP2
  output: KR266Xseries +hex
  AfterMake: FIRMWARE.BAT
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Core\header;.\PCB;.\Panel;.\OSD\OSD003;.\Keys;.\Func;.\DDCCI;.\Lib;.\Logo;.\TV;.\Flash
  group Code_0
    ./Core/code/mcu/: Timer.c Uart.c
    ./Core/code/: Auto.c FrameSync.c Mode.c Struct.c Sync.c Adjust.c Adjust_customer.c Main.c IR_Nec.c
    ./Core/code/ext_device/: video.c eeprom.c
    ./Core/code/rtd2662/: YPbPr.c Power.c Scaler.c Source.c Misc.c Hdmi.C
  group Header
    ./Core/header/: IR_Nec.h YPbPr.h Auto.h Eeprom.h EepromDefault.h FrameSync.h Global.h I2c.h Include.h Main.h MainDef.h Mcu.h Misc.h Mode.h ModeTable.h Power.h RTDAccess.h Scaler.h ScalerDef.h Struct.h Sync.h SystemTable.h Timer.h Uart.h Video.h Adjust.h Source.h Hdmi.H HdmiModeTable.H Adjust_customer.h EepromDefaultCustomer.h
    ./Keys/: Key.h
    ./Lib/: KXFunc.h
    ./OEM/: OEM.h
  group Panel
    ./Panel/: Panel.h
  group PCB
    ./PCB/: Pcb.h PCB_CF_TC2660.h PCB_CF_TC266A.h PCB800099.h
    ./Core/header/: KR_MODEL.h
  group Key_0
    ./Keys/: Key_PCB2660_003.H Key.obj Key_PCB2660_003.obj Key_PCB2660_003.c Key.c
    ./Core/code/: IR_Nec.obj
  group Func_0
    ./Func/: Func.C Func.H KX_Sc7313.c
  group OSD003_1
    ./OSD/OSD003/: OsdMenuFunc003.c OsdMenuFunc003.h OsdProc003.c OsdProc003.h OsdRes003.c OsdRes003.h OsdTable003.c OsdTable003.h OSDStruct003.h OsdFont003.c OsdFont003.h
  group TV_0
    ./TV/: TV.c TV.H JS_6B1.C JS_6B1.H JS_6B2.C JS_6B2.H TDQ6F6.C TDQ6F6.H TN8337.C TN8337.H TNJ8355.C TNJ8355.H TNJ7359.c TNJ7359.h TN835CPF.c TN835CPF.h FreqTable.C FreqTable.H JS_6AM.C JS_6AM.H CDT_3FP212.C CDT_3FP212.H CDT_3FP212_9886.C CDT_3FP212_9886.H XF_6AC.C XF_6AC.H
  group KXFunc_1
    ./OSD/: KXOSDFunc.c KXOSDFunc.h
    ./Lib/: VideoDec.H TB1338.H
  group Lib
    ./Lib/: AV_TV.obj FlashWriteDisable.obj RTD2662.obj TunerFunc.obj TB1351.obj
  group Code_Common
    ./Misc/: GUartSend.c GUartSend.h
    ./Core/code/mcu/: Int.c Mcu.c RTDAccess.c I2c.c
    ./Core/code/: L51_BANK.A51 STARTUP.A51 ST7701S.c
  group DDCCI
    ./DDCCI/: DDCCI.h DDCCIDBG.H KxExtendFunc.c KxExtendFunc.h KxExtendFuncDef.h DDCCIDBG.obj DDCCI.obj
  group Logo
    ./Logo/: Logo.c Logo.h
  group Flash
    ./Flash/: Flash.c Flash.h FlashFunc.h FlashFunc.obj
